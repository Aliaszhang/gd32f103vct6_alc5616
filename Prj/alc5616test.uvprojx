# Keil uVision project alc5616test.uvprojx, settings and files
target alc5616_test (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F103VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: alc5616test.bin +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\include;..\Lib\CMSIS\GD\GD32F10x\Include;..\Lib\GD32F10x_standard_peripheral\Include;..\Lib\CMSIS;..\source\user;..\source\driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../source/user/: gd32f10x_it.c main.c systick.c alc5616.c
  group core
    ../Lib/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
    ../Lib/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group fwlib
    ../Lib/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group driver
    ../source/driver/: fmc_operation.c gpio_driver.c i2c_driver.c spi_driver.c
